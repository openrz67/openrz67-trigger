## nrf52/firmware/boards/openrz67/openrz67_nrf/board.yml
```yaml
board:
  name: openrz67_nrf
  full_name: OpenRZ67 nRF trigger
  vendor: openrz67
  socs:
    - name: nrf54l15
```
